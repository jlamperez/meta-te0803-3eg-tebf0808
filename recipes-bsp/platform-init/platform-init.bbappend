FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI = "file://psu_init_gpl.c \
	   file://psu_init_gpl.h \
"

COMPATIBLE_MACHINE_te0803-3eg-tebf0808-zynqmp = "te0803-3eg-tebf0808-zynqmp"
